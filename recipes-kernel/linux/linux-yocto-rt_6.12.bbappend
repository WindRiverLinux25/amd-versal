require linux-yocto-amd-versal.inc

KBRANCH:amd-versal  = "v6.12/standard/preempt-rt/xlnx-soc"
